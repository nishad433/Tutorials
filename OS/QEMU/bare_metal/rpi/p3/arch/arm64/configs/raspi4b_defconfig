## OS/QEMU/bare_metal/rpi/p3/arch/arm64/configs/raspi4b_defconfig
```kconfig
CONFIG_ARCH=arm64
CONFIG_ARM64=y
CONFIG_GPIO=y
CONFIG_AUX_PERIPH=y
CONFIG_UART=y
CONFIG_GENERIC_TIMER=y
```
